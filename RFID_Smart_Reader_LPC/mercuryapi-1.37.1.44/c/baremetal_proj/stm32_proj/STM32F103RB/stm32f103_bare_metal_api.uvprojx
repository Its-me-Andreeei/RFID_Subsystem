# Keil uVision project stm32f103_bare_metal_api.uvprojx, settings and files
target stm32f103_bare_metal_api (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103_bare_metal_api +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BARE_METAL
  c include: ..\..\..\src\api
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source file
    ../../../src/api/: hex_bytes.c osdep_stm32F103RB.c serial_reader.c serial_reader_l3.c serial_transport_stm32F103RB.c tm_reader.c tm_reader_async.c tmr_param.c tmr_strerror.c tmr_utils.c
    ../../../src/samples/: read.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
