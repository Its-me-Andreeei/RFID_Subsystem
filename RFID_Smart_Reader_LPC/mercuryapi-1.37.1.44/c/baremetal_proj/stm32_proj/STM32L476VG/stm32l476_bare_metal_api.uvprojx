# Keil uVision project stm32l476_bare_metal_api.uvprojx, settings and files
target stm32l476_bare_metal_api (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32l476_bare_metal_api +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BARE_METAL,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=4000000,EXTERNALSAI1_CLOCK_VALUE=2097000,EXTERNALSAI2_CLOCK_VALUE=2097000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32L476xx
  c include: .\Inc;.\Drivers\STM32L4xx_HAL_Driver\Inc;.\Drivers\CMSIS\Device\ST\STM32L4xx\Include;.\Drivers\CMSIS\Include;..\..\..\src\api
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ./Src/: stm32l4xx_it.c
    ../../../src/api/: hex_bytes.c osdep_stm32L476VG.c serial_reader.c serial_reader_l3.c serial_transport_stm32L476VG.c tm_reader.c tm_reader_async.c tmr_param.c tmr_strerror.c tmr_utils.c
    ../../../src/samples/: read.c
  group Drivers/STM32L4xx_HAL_Driver
    ./Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_exti.c stm32l4xx_ll_utils.c stm32l4xx_ll_gpio.c stm32l4xx_ll_pwr.c stm32l4xx_ll_dma.c stm32l4xx_ll_rcc.c stm32l4xx_ll_usart.c
  group Drivers/CMSIS
    ./Src/: system_stm32l4xx.c
software components: CMSIS:CORE 5.3.0
