# Keil uVision project rfid.uvproj, settings and files
target LPC2994 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2294 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: rfid +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: BARE_METAL, DEBUG_TX_RX
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  link misc: --info=summarystack
  group Main
    ./: Startup.s main.c Retarget.c
  group Utils
    ./utils/: ringbuf.c timer_software.c
  group HAL
    ./hal/: timer.c uart0.c uart1.c ISR_manager.c i2c.c
  group MercuryAPI
    ./mercuryapi-1.37.1.44/c/src/api/: hex_bytes.c osdep_dummy.c serial_reader.c serial_reader_l3.c serial_transport_dummy.c tm_reader.c tm_reader_async.c tmr_param.c tmr_strerror.c tmr_utils.c
  group ASW
    ./ASW/ReaderManager/: reader_manager.c
