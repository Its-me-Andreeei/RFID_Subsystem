# Keil uVision project memorytest.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: memorytest +hex
  c flags: Optim=4
  c include: .\Code
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./Code/: main.c Startup.s global.c Retarget.c Serial.c
  group Flash_IntelTE28F320C3
    ./Code/Flash_IntelTE28F320C3/: Flash_IntelTE28F320C3.c
