# Keil uVision project memorytest.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: memorytest +hex
  c flags: Optim=1
  c include: .\Code
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./Code/: main.c Startup.s global.c Retarget.c Serial.c flash_test.c
  group Flash_ST_M29W320DB
    ./Code/Flash_STM29W320DB/: flash_stm29w320db.c
